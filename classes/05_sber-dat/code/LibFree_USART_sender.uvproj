# Keil uVision project LibFree_USART_sender.uvproj, settings and files
target LibFree_USART_sender (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LibFree_USART_sender
  c flags: Optim=1
  c include: .\Libraries
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./Source/: main.c
  group Startup
    ./Libraries/: startup_stm32f10x_md_vl.s
  group Libraries
    ./Libraries/: core_cm3.c
